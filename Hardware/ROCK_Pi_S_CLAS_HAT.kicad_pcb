# Repository takuhoTech/CelestNavi-HAT-for-ROCK-Pi-S

File README.md:

# 星導 CelestNavi-HAT for ROCK Pi S
ROCK Pi S CLAS HAT

## KiCad design Hardware/ROCK_Pi_S_CLAS_HAT.kicad_pcb

Parts:
BT1: MS421R; Battery_Seiko_MS421R
C1, C7: 0.1u; C_0603_1608Metric; LCSC C14663
C2: 470p; C_0603_1608Metric; LCSC C1620
C3: 22u; C_0805_2012Metric; LCSC C45783
C4, C9, C10, C11, C12: 1u; C_0603_1608Metric; LCSC C15849
C5: GJM1555C1H470FB01D; C_Murata_xxx15_0402_1005Metric_1.0x0.5mm; LCSC C882562
C6: 0.1u; C_0402_1005Metric; LCSC C307331
C8: 2.2u; C_0603_1608Metric; LCSC C23630
D1, D2, D4, D5: CUHS20S30; D_Toshiba_US2H; LCSC C5636538
D3: AXGD10402KR; D_Littelfuse_AXGD10402KR_0402_1005Metric_1.02x0.51mm; LCSC C434715
D6: PULSE(WHITE); LED_0603_1608Metric; LCSC C2290
D7: RTK(YELLOW); LED_0603_1608Metric; LCSC C72038
D8: PWR(RED); LED_0603_1608Metric; LCSC C2286
J1: ROCK_Pi_S; not fitted
J2, J4: GT-USB-7025; USB_C_Receptacle_G-Switch_GT-USB-7025; LCSC C963213
J3: U.FL-R-SMT-1; U.FL_Hirose_U.FL-R-SMT-1_Vertical; LCSC C88374
L1: LQW18ANR12G80D; L_Murata_LQW18ANxxxx80x_0603_1608Metric_1.65x0.99mm; LCSC C307612
Q1, Q2: AO3400A; SOT-23; LCSC C20917
R1, R2, R5, R6: 5.1k; R_0603_1608Metric; LCSC C23186
R3: 10; R_0402_1005Metric; LCSC C25077
R4: FC0603E1000BTBT1; R_Vishay_FC0603xxxxxxTxx_0603_1608Metric_1.626x0.813mm; LCSC C3999268
R7, R8, R9, R10, R11, R12, R13, R14, R15: 33; R_0603_1608Metric; LCSC C23140
R16, R17, R25: 1k; R_0603_1608Metric; LCSC C21190
R18: 3.3k; R_0603_1608Metric; LCSC C22978
R19, R24: 100k; R_0603_1608Metric; LCSC C25803
R20, R23: 10k; R_0603_1608Metric; LCSC C25804
R21, R22: 47; R_0603_1608Metric; LCSC C23182
TP1: EXTINT_F9R; TestPoint_Pad_D1.0mm; not fitted
TP2: ~{SAFEBOOT_F9R}; TestPoint_Pad_D1.0mm; not fitted
TP3: ~{RESET_F9R}; TestPoint_Pad_D1.0mm; not fitted
TP4: EXTINT_D9C; TestPoint_Pad_D1.0mm; not fitted
TP5: ~{SAFEBOOT_D9C}; TestPoint_Pad_D1.0mm; not fitted
TP6: ~{RESET_D9C}; TestPoint_Pad_D1.0mm; not fitted
U1: BPI-9600; Converter_DCDC_BananaPi_BPI-9600; not fitted
U2, U7: USBLC6-2SC6; SOT-23-6; LCSC C7519
U3: MIC5219-3.3YM5; SOT-23-5; LCSC C29613
U4: ZED-F9R; ublox_ZED; LCSC C5189233
U5: NEO-D9C; ublox_NEO; LCSC C5137014
U6: PD0922J5050S2HF; Xinger_0805_2012Metric-6_Pad0.33x0.41mm; LCSC C5136968

Connections:
+3.3V: C3.1, C9.1, C10.1, D5.2 (A), Q1.3 (D), Q2.3 (D), R17.1, R25.1, U3.5 (OUT), U4.33 (VCC), U4.34 (VCC), U5.23 (VCC)
+3.3VA: R3.1, U4.7 (VCC_RF)
+5V: D1.2 (A), J1.2, J1.4, U1.6 (+VDC)
+BATT: BT1.1 (+), C8.1, R18.2, U4.36 (V_BCKP)
/D+D9C: R13.1, U7.4 (I/O2)
/D+F9R: R8.2, U2.4 (I/O2)
/D-D9C: R12.1, U7.6 (I/O1)
/D-F9R: R7.2, U2.6 (I/O1)
/GEO: J1.15, U4.19 (GEOFENCE_STAT)
/RF_IN_D9C: R4.2, U5.11 (RF_IN), U6.6 (Output2)
/RF_IN_F9R: R4.1, U4.2 (RF_IN), U6.4 (Output1)
/RTK: D7.1 (K), J1.13, U4.20 (RTK_STAT)
/RXD0_ROCK: J1.10
/RXD1_ROCK: J1.23, R9.2
/RXD2_ROCK: J1.21, R10.2
/SCL1: J1.5, U4.45 (SCL/SPI_CLK), U5.19 (SCL/SPI_CLK)
/SDA1: J1.3, R11.2, R15.1
/TP: J1.11, R16.1, U4.53 (TIMEPULSE)
/TXD0_ROCK: J1.8
/TXD1_ROCK: J1.24, U4.43 (RXD/SPI_MOSI)
/TX_READY_F9R: J1.7, U4.46 (TX_READY)
/VBUS_D9C: C7.1, D4.2 (A), J4.A4 (VBUS), J4.A9 (VBUS), J4.B4 (VBUS), J4.B9 (VBUS), R22.1, U7.5 (VBUS)
/VBUS_F9R: C1.1, D2.2 (A), J2.A4 (VBUS), J2.A9 (VBUS), J2.B4 (VBUS), J2.B9 (VBUS), R21.1, U2.5 (VBUS)
/V_USB_D9C: C12.1, Q2.2 (S), R24.1, U5.7 (V_USB)
/V_USB_F9R: C11.1, Q1.2 (S), R19.1, U4.38 (V_USB)
GND: BT1.2 (-), C1.2, C2.2, C3.2, C4.2, C6.2, C7.2, C8.2, C9.2, C10.2, C11.2, C12.2, D3.1 (A1), D6.1 (K), D8.1 (K), J1.6, J1.9, J1.14, J1.20, J1.25, J1.27, J2.A1 (GND), J2.A12 (GND), J2.B1 (GND), J2.B12 (GND), J2.GND, J2.S1 (SHIELD), J3.2 (Ext), J4.A1 (GND), J4.A12 (GND), J4.B1 (GND), J4.B12 (GND), J4.GND, J4.S1 (SHIELD), R1.2, R2.2, R5.2, R6.2, R19.2, R20.2, R23.2, R24.2, U1.5 (-VDC), U2.2 (GND), U3.2 (GND), U4.1 (GND), U4.3 (GND), U4.12 (GND), U4.14 (GND), U4.32 (GND), U4.37 (GND), U4.41 (GND), U4.48 (GND), U4.55 (GND), U5.10 (GND), U5.12 (GND), U5.13 (GND), U5.24 (GND), U6.1 (GND), U6.3 (GND), U6.5 (GND), U7.2 (GND)
unnamed: C6.1, L1.1, R3.2
unnamed: C5.1, D3.2 (A2), J3.1 (In), L1.2
unnamed: D5.1 (K), R18.1
unnamed: D6.2 (A), R16.2
unnamed: D7.2 (A), R17.2
unnamed: D8.2 (A), R25.2
unnamed: J1.53, U1.1 (VA1)
unnamed: J1.54, U1.2 (VA2)
unnamed: J1.55, U1.3 (VB1)
unnamed: J1.56, U1.4 (VB2)
unnamed: J2.A5 (CC1), R1.1
unnamed: J2.B5 (CC2), R2.1
unnamed: J2.A6 (D+), J2.B6 (D+), U2.3 (I/O2)
unnamed: J2.A7 (D-), J2.B7 (D-), U2.1 (I/O1)
unnamed: J4.A5 (CC1), R5.1
unnamed: J4.B5 (CC2), R6.1
unnamed: J4.A6 (D+), J4.B6 (D+), U7.3 (I/O2)
unnamed: J4.A7 (D-), J4.B7 (D-), U7.1 (I/O1)
unnamed: Q1.1 (G), R20.1, R21.2
unnamed: Q2.1 (G), R22.2, R23.1
unnamed: C2.1, U3.4 (BP)
unnamed: TP1.1, U4.51 (EXTINT)
unnamed: R14.1, U4.26 (RXD2)
unnamed: R11.1, U4.44 (SDA/~SPI_CS)
unnamed: R10.1, U4.27 (TXD2)
unnamed: R9.1, U4.42 (TXD/SPI_MISO)
unnamed: R7.1, U4.39 (USB_DM)
unnamed: R8.1, U4.40 (USB_DP)
unnamed: TP3.1, U4.49 (~RESET)
unnamed: TP2.1, U4.50 (~SAFEBOOT)
unnamed: TP4.1, U5.17 (EXTINT)
unnamed: R15.2, U5.18 (SDA/~SPI_CS)
unnamed: R14.2, U5.20 (TXD/SPI_MISO)
unnamed: R12.2, U5.5 (USB_DM)
unnamed: R13.2, U5.6 (USB_DP)
unnamed: TP6.1, U5.8 (~RESET)
unnamed: TP5.1, U5.1 (~SAFEBOOT)
unnamed: C5.2, U6.2 (Input)
VDD: C4.1, D1.1 (K), D2.1 (K), D4.1 (K), U3.1 (IN), U3.3 (EN)

Notes on the sheet:
DC-Blocking
抵抗R4について
I2C+UART only
Power
SIZE: TCR: RESISTANCE: TOLERANCE: TERMINATION: PACK:
USBのダンピング抵抗の27Ωはbasicに無いため33Ωに統一
0603(1608)のみ Eのみ 1000(100Ω)のみ 高精度の方が望ましい top sidedのうち鉛フリーでないものが望ましい どれでもよい
Interface
USB availability detection

Board: 4 copper layers, 43.2 x 43.2 mm, 66 parts (1 on the bottom side), 63 nets.

File Hardware/production/bom.csv:

Designator,Footprint,Quantity,Value,LCSC Part #
BT1,Battery_Seiko_MS421R,1,MS421R,
"C1, C7",0603,2,0.1u,C14663
"C10, C11, C12, C4, C9",0603,5,1u,C15849
C2,0603,1,470p,C1620
C3,0805,1,22u,C45783
C5,C_Murata_xxx15_0402_1005Metric_1.0x0.5mm,1,GJM1555C1H470FB01D,C882562
C6,0402,1,0.1u,C307331
C8,0603,1,2.2u,C23630
"D1, D2, D4, D5",D_Toshiba_US2H,4,CUHS20S30,C5636538
D3,D_Littelfuse_AXGD10402KR_0402_1005Metric_1.02x0.51mm,1,AXGD10402KR,C434715
D6,0603,1,PULSE(WHITE),C2290
D7,0603,1,RTK(YELLOW),C72038
D8,0603,1,PWR(RED),C2286
J1,ROCK_Pi_S,1,ROCK_Pi_S,
"J2, J4",USB_C_Receptacle_G-Switch_GT-USB-7025,2,GT-USB-7025,C963213
J3,U.FL_Hirose_U.FL-R-SMT-1_Vertical,1,U.FL-R-SMT-1,C88374
L1,L_Murata_LQW18ANxxxx80x_0603_1608Metric_1.65x0.99mm,1,LQW18ANR12G80D,C307612
"Q1, Q2",SOT-23,2,AO3400A,C20917
"R1, R2, R5, R6",0603,4,5.1k,C23186
"R10, R11, R12, R13, R14, R15, R7, R8, R9",0603,9,33,C23140
"R16, R17, R25",0603,3,1k,C21190
R18,0603,1,3.3k,C22978
"R19, R24",0603,2,100k,C25803
"R20, R23",0603,2,10k,C25804
"R21, R22",0603,2,47,C23182
R3,0402,1,10,C25077
R4,R_Vishay_FC0603xxxxxxTxx_0603_1608Metric_1.626x0.813mm,1,FC0603E1000BTBT1,C3999268
TP1,TestPoint_Pad_D1.0mm,1,EXTINT_F9R,
TP2,TestPoint_Pad_D1.0mm,1,~{SAFEBOOT_F9R},
TP3,TestPoint_Pad_D1.0mm,1,~{RESET_F9R},
TP4,TestPoint_Pad_D1.0mm,1,EXTINT_D9C,
TP5,TestPoint_Pad_D1.0mm,1,~{SAFEBOOT_D9C},
TP6,TestPoint_Pad_D1.0mm,1,~{RESET_D9C},
U1,Converter_DCDC_BananaPi_BPI-9600,1,BPI-9600,
"U2, U7",SOT-23-6,2,USBLC6-2SC6,C7519
U3,SOT-23-5,1,MIC5219-3.3YM5,C29613
U4,ublox_ZED,1,ZED-F9R,C5189233
U5,ublox_NEO,1,NEO-D9C,C5137014
U6,Xinger_0805_2012Metric-6_Pad0.33x0.41mm,1,PD0922J5050S2HF,C5136968

## Commit log

2025-02-12 add KiCad Project
2025-02-17 電源設計完了
2025-02-24 フットプリントの割り当てまで完了
2025-02-25 LCSC番号を割り当て
2025-02-25 update PCB
2025-03-04 LED追加
2025-03-06 USBコネクタを変更
2025-03-08 アートワーク設計完了
2025-04-16 add fab file
